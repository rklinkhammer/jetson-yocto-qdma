# Allow dtc to emit YAML as well as DTS, DTB and assembler output.
PACKAGECONFIG:append = " yaml"
